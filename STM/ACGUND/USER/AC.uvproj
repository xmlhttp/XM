# Keil uVision project AC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AC +hex
  AfterMake: E:\work\soft\stm32\ARM\BIN40\fromelf.exe  --bin -o  ..\OBJ\AC.bin ..\OBJ\AC.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\MALLOC;..\USMART;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DM9000;..\UCOSII\CONFIG;..\UCOSII\PORT;..\UCOSII\CORE;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\web_server_demo;..\HARDWARE\ITEMP;..\FWLIB\STM32F10x_FWLib\inc;..\LWIP\lwip_app\tcp_client_demo;..\HARDWARE\ADC;..\HARDWARE\pwm;..\HARDWARE\BEEP;..\HARDWARE\usart2;..\HARDWARE\modbus;..\HARDWARE\usart3;..\HARDWARE\exti;..\HARDWARE\STMFLASH;..\HARDWARE\tools;..\LWIP\lwip_app\http_client;..\HARDWARE\GPIOS;..\HARDWARE\LWDG
  memory RVCT4: ROM 0x8007800 size 0x78800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/DM9000/: dm9000.h dm9000.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/pwm/: pwm.c
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/modbus/: mod.c mod.h
    ../HARDWARE/usart2/: usart2.h usart2.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/exti/: exti.h exti.c
    ../HARDWARE/STMFLASH/: stmflash.c stmflash.h
    ../HARDWARE/tools/: cJSON.c
    ../HARDWARE/GPIOS/: gpios.c
    ../HARDWARE/LWDG/: LWDG.c
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_iwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c fs.h
    ../LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c tcp_client_demo.h
    ../LWIP/lwip_app/http_client/: http.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
